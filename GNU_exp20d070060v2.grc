options:
  parameters:
    generate_options: qt_gui
    id: GNU_exp20d070060
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: n
  id: variable
  parameters:
    value: '1600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '26'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_0_0_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_0_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_0_2
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_1_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_1_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_2
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_2_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_0_3
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_1_0_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_1_0_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_1_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_1_2
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_2_1
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: n
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\prate\Desktop\GNU Radio Files\Signal_20D070060.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '3'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '40000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_delay_0_1, '0']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_0_0, '0', blocks_delay_0_2, '0']
- [blocks_delay_0_0_0_0, '0', blocks_add_xx_0, '7']
- [blocks_delay_0_0_0_0, '0', blocks_delay_0_3, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_add_xx_0, '15']
- [blocks_delay_0_0_0_0_0, '0', blocks_delay_0_4, '0']
- [blocks_delay_0_0_0_0_1, '0', blocks_add_xx_0, '23']
- [blocks_delay_0_0_0_0_1, '0', blocks_delay_0_3_0, '0']
- [blocks_delay_0_0_0_1, '0', blocks_add_xx_0, '11']
- [blocks_delay_0_0_0_1, '0', blocks_delay_0_2_0, '0']
- [blocks_delay_0_0_0_2, '0', blocks_add_xx_0, '19']
- [blocks_delay_0_0_0_2, '0', blocks_delay_0_2_1, '0']
- [blocks_delay_0_0_1, '0', blocks_add_xx_0, '5']
- [blocks_delay_0_0_1, '0', blocks_delay_0_1_0, '0']
- [blocks_delay_0_0_1_0, '0', blocks_add_xx_0, '13']
- [blocks_delay_0_0_1_0, '0', blocks_delay_0_1_0_0, '0']
- [blocks_delay_0_0_1_1, '0', blocks_add_xx_0, '21']
- [blocks_delay_0_0_1_1, '0', blocks_delay_0_1_0_1, '0']
- [blocks_delay_0_0_2, '0', blocks_add_xx_0, '9']
- [blocks_delay_0_0_2, '0', blocks_delay_0_1_1, '0']
- [blocks_delay_0_0_2_0, '0', blocks_add_xx_0, '25']
- [blocks_delay_0_0_3, '0', blocks_add_xx_0, '17']
- [blocks_delay_0_0_3, '0', blocks_delay_0_1_2, '0']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_1, '0', blocks_delay_0_0_0, '0']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0, '6']
- [blocks_delay_0_1_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_delay_0_1_0_0, '0', blocks_add_xx_0, '14']
- [blocks_delay_0_1_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_delay_0_1_0_1, '0', blocks_add_xx_0, '22']
- [blocks_delay_0_1_0_1, '0', blocks_delay_0_0_0_0_1, '0']
- [blocks_delay_0_1_1, '0', blocks_add_xx_0, '10']
- [blocks_delay_0_1_1, '0', blocks_delay_0_0_0_1, '0']
- [blocks_delay_0_1_2, '0', blocks_add_xx_0, '18']
- [blocks_delay_0_1_2, '0', blocks_delay_0_0_0_2, '0']
- [blocks_delay_0_2, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_2, '0', blocks_delay_0_0_1, '0']
- [blocks_delay_0_2_0, '0', blocks_add_xx_0, '12']
- [blocks_delay_0_2_0, '0', blocks_delay_0_0_1_0, '0']
- [blocks_delay_0_2_1, '0', blocks_add_xx_0, '20']
- [blocks_delay_0_2_1, '0', blocks_delay_0_0_1_1, '0']
- [blocks_delay_0_3, '0', blocks_add_xx_0, '8']
- [blocks_delay_0_3, '0', blocks_delay_0_0_2, '0']
- [blocks_delay_0_3_0, '0', blocks_add_xx_0, '24']
- [blocks_delay_0_3_0, '0', blocks_delay_0_0_2_0, '0']
- [blocks_delay_0_4, '0', blocks_add_xx_0, '16']
- [blocks_delay_0_4, '0', blocks_delay_0_0_3, '0']
- [blocks_wavfile_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
