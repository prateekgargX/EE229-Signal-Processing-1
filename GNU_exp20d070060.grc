options:
  parameters:
    generate_options: qt_gui
    id: GNU_exp20d070060
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '640'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '400'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '320'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\prate\Desktop\GNU Radio Files\Signal_20D070060.wav
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '40000'
    srate: samp_rate
    type: float
    ylabel: 1000Hz
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '40000'
    srate: samp_rate
    type: float
    ylabel: 800Hz
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '40000'
    srate: samp_rate
    type: float
    ylabel: 640Hz
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '40000'
    srate: samp_rate
    type: float
    ylabel: 320Hz
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '40000'
    srate: samp_rate
    type: float
    ylabel: 400Hz
    ymax: '4'
    ymin: '-4'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_sub_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [analog_sig_source_x_0_0_0_0_0, '0', blocks_sub_xx_0_0_0_0_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_sub_xx_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
