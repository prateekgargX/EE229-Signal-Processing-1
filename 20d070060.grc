options:
  parameters:
    generate_options: qt_gui
    id: 20d070060
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\prate\Desktop\GNU Radio Files\Signal_20D070060.wav
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-0.5'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
